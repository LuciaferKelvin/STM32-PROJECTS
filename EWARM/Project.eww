<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\429IGV101.ewp</path>
  </project>
  <batchBuild />
</workspace>
